# KOMPAS-3D part (ZARDP 050.040.10.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2

Texts:
  ООО ИК Энерпред-Ярдос